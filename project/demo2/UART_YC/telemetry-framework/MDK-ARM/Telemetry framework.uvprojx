# Keil uVision project Telemetry framework.uvprojx, settings and files
target Telemetry framework (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Telemetry framework +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --cpp11
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../Algorithm;../Appliaction;../boards;../Device/IMU/BMI088;../Device/Motor/Motor_DJI;../Device/Motor/Motor_QD4310;../Device/IMU/BMI088/Mahony;../Device/Hardware
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group boards
    ../boards/: bsp.h drv_spi.c drv_can.cpp drv_uart.cpp uart_protocol.c host_uart.c bsp_buzzer.c bsp_led.c bsp_key.c bsp_oled.c tool_delay.c tool_debug.c tool_math.cpp tool_serialplot.cpp
  group applicaton
    ../Appliaction/: Timer_task.c imu_tempctrl_task.c Communication_task.c
  group Algorithm
    ../Algorithm/: pid.c alg_pid.cpp
  group Hardware
    ../Device/Hardware/: TB6612.c RC_SBUS.c
  group IMU
    ../Device/IMU/BMI088/Mahony/: MahonyAHRS.c
    ../Device/IMU/BMI088/: BMI088driver.c BMI088Middleware.c
  group Motor
    ../Device/Motor/Motor_DJI/: dvc_motor_dji.cpp
    ../Device/Motor/Motor_QD4310/: QD4310.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 4.3.0
